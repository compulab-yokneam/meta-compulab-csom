FILESEXTRAPATHS:prepend := "${THISDIR}/imx8mp-ucm-imx8m-plus:"
require imx8mp-ucm-imx8m-plus.inc
