FILESEXTRAPATHS_prepend := "${THISDIR}/custom-som:"

SRC_URI_append = " \
	file://0100-Add-a-sample-empty-custom.file-to-the-tree.patch \
"
